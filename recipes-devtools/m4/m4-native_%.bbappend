FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0003-c-stack-stop-using-SIGSTKSZ.patch"

